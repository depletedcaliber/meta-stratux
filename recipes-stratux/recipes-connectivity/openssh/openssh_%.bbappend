FILESEXTRAPATHS_prepend := "${THISDIR}/openssh:"

SYSTEMD_AUTO_ENABLE = "enable"
